# Keil uVision project STM32-DSP-CAN-Boot.uvprojx, settings and files
target DSP_Boot (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32-DSP-CAN-Boot +hex
  AfterMake: fromelf.exe --bin -o $L@H.bin $L@H.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4
  c include: ..\bsp\inc;..\CMSIS\inc;..\FatFs\inc;..\DSP_CAN_IAP\inc;..\STM32F4xx_StdPeriph_Driver\inc;..\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/src/: main.c stm32f4xx_it.c user_config.c
  group bsp
    ../bsp/src/: delay.c
  group BootLoader
    ../DSP_CAN_IAP/src/: IAP.c CANA.c
  group FatFs
    ../FatFs/src/: diskio.c ff.c sdio_sd.c syscall.c unicode.c
  group Lib
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group CMSIS
    ../CMSIS/asm/: startup_stm32f40_41xxx.s
    ../CMSIS/src/: system_stm32f4xx.c
